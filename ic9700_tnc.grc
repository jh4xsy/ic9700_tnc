options:
  parameters:
    author: JH4XSY/1
    generate_options: no_gui
    id: ic9700_tnc
    output_language: python
    run_options: run
    title: TNC frontend for IC9700
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.2'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:1,0
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: destination
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: destination
    port: port+10
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: destination
    port: port+20
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: destination
  id: parameter
  parameters:
    label: destination
    type: str
    value: localhost
  states: {}
- name: filter_width
  id: parameter
  parameters:
    label: FM filter width
    type: eng_float
    value: '20000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_width/2.0, filter_width/20.0)
    type: fcc
  states: {}
- name: note_0
  id: note
  parameters:
    note: 9k6
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: 4k8
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: 1k2
  states: {}
- name: note_0_0_0_1
  id: note
  parameters:
    note: set USB output = IF
  states: {}
- name: note_0_0_0_1_0_0
  id: note
  parameters:
    note: Audio over UDP to TNC
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 12e3
  states: {}
- name: port
  id: parameter
  parameters:
    label: port
    type: intx
    value: '7355'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-30'
    int_min: '-80'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-30'
    int_min: '-80'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0_0, '0', blocks_float_to_short_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [audio_source_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0_0_1, '0']

metadata:
  file_format: 1
